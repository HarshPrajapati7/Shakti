#ifndef DOTO_FONT_H
#define DOTO_FONT_H

#include <Arduino.h>
#include <Adafruit_GFX.h>
#include <Adafruit_GC9A01A.h>

// ── Doto / Nothing OS Style Dot-Matrix Font ─────────
// Compact 5x7 bitmap matrix rendered as discrete circular / square LED dots
static const uint8_t doto_glyphs[95 * 5] = {
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x5F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x14, 0x7F, 0x14, 0x7F, 0x14, 0x24, 0x2A, 0x7F, 0x2A, 0x12, 0x23, 0x13, 0x08, 0x64, 0x62,
  0x36, 0x49, 0x56, 0x20, 0x50, 0x00, 0x08, 0x07, 0x03, 0x00, 0x00, 0x1C, 0x22, 0x41, 0x00,
  0x00, 0x41, 0x22, 0x1C, 0x00, 0x2A, 0x1C, 0x7F, 0x1C, 0x2A, 0x08, 0x08, 0x3E, 0x08, 0x08,
  0x00, 0x80, 0x70, 0x30, 0x00, 0x08, 0x08, 0x08, 0x08, 0x08, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x3E, 0x51, 0x49, 0x45, 0x3E, 0x00, 0x42, 0x7F, 0x40, 0x00,
  0x72, 0x49, 0x49, 0x49, 0x46, 0x21, 0x41, 0x49, 0x4D, 0x33, 0x18, 0x14, 0x12, 0x7F, 0x10,
  0x27, 0x45, 0x45, 0x45, 0x39, 0x3C, 0x4A, 0x49, 0x49, 0x31, 0x41, 0x21, 0x11, 0x09, 0x07,
  0x36, 0x49, 0x49, 0x49, 0x36, 0x46, 0x49, 0x49, 0x29, 0x1E, 0x00, 0x00, 0x14, 0x00, 0x00,
  0x00, 0x40, 0x34, 0x00, 0x00, 0x00, 0x08, 0x14, 0x22, 0x41, 0x14, 0x14, 0x14, 0x14, 0x14,
  0x00, 0x41, 0x22, 0x14, 0x08, 0x02, 0x01, 0x59, 0x09, 0x06, 0x3E, 0x41, 0x5D, 0x59, 0x4E,
  0x7C, 0x12, 0x11, 0x12, 0x7C, 0x7F, 0x49, 0x49, 0x49, 0x36, 0x3E, 0x41, 0x41, 0x41, 0x22,
  0x7F, 0x41, 0x41, 0x41, 0x3E, 0x7F, 0x49, 0x49, 0x49, 0x41, 0x7F, 0x09, 0x09, 0x09, 0x01,
  0x3E, 0x41, 0x41, 0x51, 0x73, 0x7F, 0x08, 0x08, 0x08, 0x7F, 0x00, 0x41, 0x7F, 0x41, 0x00,
  0x20, 0x40, 0x41, 0x3F, 0x01, 0x7F, 0x08, 0x14, 0x22, 0x41, 0x7F, 0x40, 0x40, 0x40, 0x40,
  0x7F, 0x02, 0x1C, 0x02, 0x7F, 0x7F, 0x04, 0x08, 0x10, 0x7F, 0x3E, 0x41, 0x41, 0x41, 0x3E,
  0x7F, 0x09, 0x09, 0x09, 0x06, 0x3E, 0x41, 0x51, 0x21, 0x5E, 0x7F, 0x09, 0x19, 0x29, 0x46,
  0x26, 0x49, 0x49, 0x49, 0x32, 0x03, 0x01, 0x7F, 0x01, 0x03, 0x3F, 0x40, 0x40, 0x40, 0x3F,
  0x1F, 0x20, 0x40, 0x20, 0x1F, 0x3F, 0x40, 0x38, 0x40, 0x3F, 0x63, 0x14, 0x08, 0x14, 0x63,
  0x03, 0x04, 0x78, 0x04, 0x03, 0x61, 0x59, 0x49, 0x4D, 0x43, 0x00, 0x7F, 0x41, 0x41, 0x41,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x00, 0x41, 0x41, 0x41, 0x7F, 0x04, 0x02, 0x01, 0x02, 0x04,
  0x40, 0x40, 0x40, 0x40, 0x40, 0x00, 0x03, 0x07, 0x08, 0x00, 0x20, 0x54, 0x54, 0x78, 0x40,
  0x7F, 0x28, 0x44, 0x44, 0x38, 0x38, 0x44, 0x44, 0x44, 0x28, 0x38, 0x44, 0x44, 0x28, 0x7F,
  0x38, 0x54, 0x54, 0x54, 0x18, 0x00, 0x08, 0x7E, 0x09, 0x02, 0x18, 0xA4, 0xA4, 0x9C, 0x78,
  0x7F, 0x08, 0x04, 0x04, 0x78, 0x00, 0x44, 0x7D, 0x40, 0x00, 0x20, 0x40, 0x40, 0x3D, 0x00,
  0x7F, 0x10, 0x28, 0x44, 0x00, 0x00, 0x41, 0x7F, 0x40, 0x00, 0x7C, 0x04, 0x78, 0x04, 0x78,
  0x7C, 0x08, 0x04, 0x04, 0x78, 0x38, 0x44, 0x44, 0x44, 0x38, 0xFC, 0x18, 0x24, 0x24, 0x18,
  0x18, 0x24, 0x24, 0x18, 0xFC, 0x7C, 0x08, 0x04, 0x04, 0x08, 0x48, 0x54, 0x54, 0x54, 0x24,
  0x04, 0x04, 0x3F, 0x44, 0x24, 0x3C, 0x40, 0x40, 0x20, 0x7C, 0x1C, 0x20, 0x40, 0x20, 0x1C,
  0x3C, 0x40, 0x30, 0x40, 0x3C, 0x44, 0x28, 0x10, 0x28, 0x44, 0x4C, 0x90, 0x90, 0x90, 0x7C,
  0x44, 0x64, 0x54, 0x4C, 0x44, 0x00, 0x08, 0x36, 0x41, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x00, 0x41, 0x36, 0x08, 0x00, 0x02, 0x01, 0x02, 0x04, 0x02,
};

// Measure string width in pixels
inline int16_t dotoTextWidth(const char* str, uint8_t pitch = 3) {
  if (!str) return 0;
  int16_t len = strlen(str);
  if (len == 0) return 0;
  return len * (5 * pitch + pitch) - pitch;
}

// Draw a single Doto dot-matrix character
inline void drawDotoChar(Adafruit_GC9A01A &tft, int16_t x, int16_t y, char c, 
                         uint16_t fgColor, uint16_t bgDotColor = 0, 
                         uint8_t dotRadius = 1, uint8_t pitch = 3) {
  if (c < 32 || c > 126) c = ' ';
  uint16_t offset = (c - 32) * 5;

  for (int8_t col = 0; col < 5; col++) {
    uint8_t colBits = doto_glyphs[offset + col];
    for (int8_t row = 0; row < 7; row++) {
      int16_t dx = x + col * pitch;
      int16_t dy = y + row * pitch;

      if (colBits & (1 << row)) {
        // Active dot
        if (dotRadius <= 1) {
          tft.drawPixel(dx, dy, fgColor);
          if (pitch >= 3) {
            tft.drawPixel(dx + 1, dy, fgColor);
            tft.drawPixel(dx, dy + 1, fgColor);
            tft.drawPixel(dx + 1, dy + 1, fgColor);
          }
        } else {
          tft.fillCircle(dx + dotRadius - 1, dy + dotRadius - 1, dotRadius, fgColor);
        }
      } else if (bgDotColor != 0) {
        // Inactive LED matrix dot (CMF / Nothing ambient dot)
        tft.drawPixel(dx, dy, bgDotColor);
      }
    }
  }
}

// Draw Doto dot-matrix string
inline void drawDotoString(Adafruit_GC9A01A &tft, int16_t x, int16_t y, const char* str, 
                           uint16_t fgColor, uint16_t bgDotColor = 0, 
                           uint8_t dotRadius = 1, uint8_t pitch = 3) {
  if (!str) return;
  int16_t curX = x;
  int16_t charStep = 5 * pitch + pitch;
  while (*str) {
    drawDotoChar(tft, curX, y, *str, fgColor, bgDotColor, dotRadius, pitch);
    curX += charStep;
    str++;
  }
}

// Draw horizontally centered Doto string
inline void drawDotoCenter(Adafruit_GC9A01A &tft, int16_t centerX, int16_t y, const char* str, 
                           uint16_t fgColor, uint16_t bgDotColor = 0, 
                           uint8_t dotRadius = 1, uint8_t pitch = 3) {
  int16_t w = dotoTextWidth(str, pitch);
  int16_t x = centerX - (w / 2);
  drawDotoString(tft, x, y, str, fgColor, bgDotColor, dotRadius, pitch);
}

#endif // DOTO_FONT_H
